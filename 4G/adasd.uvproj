# Keil uVision project adasd.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2102 NXP
  cpu: IRAM(0x40000000-0x40000FFF) IROM(0-0x3FFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: adasd
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x40000000 size 0x1000
  group Source Group 1
    ./: Startup.s
